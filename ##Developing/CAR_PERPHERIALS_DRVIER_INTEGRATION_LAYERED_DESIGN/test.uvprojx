# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./driverlib/rvmdk/: driverlib.lib
    ./: main.c UART.c global.c
  group motor
    ./motor/: Motor_DIO.c Motor_PWM.c Motor_PID.c
  group encoder
    ./encoder/: Encoder.c
  group servo
    ./servo/: Servo.c
  group CarIF
    ./CarIF/: CarIF.c
  group Ultrasonic
    ./Ultrasonic/: Ultrasonic.c
software components: CMSIS:CORE 5.0.2, Device:Startup 1.0.1
